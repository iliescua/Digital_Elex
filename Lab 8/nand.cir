This is a simulated NAND gate for prelab 8

.SUBCKT 2N7000/ON 1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Mar 31, 04
* MODEL FORMAT: PSpice
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
* Default values used in MM:
* The voltage-dependent capacitances are
* not included. Other default values are:
*   RS=0 RD=0 LD=0 CBD=0 CBS=0 CGBO=0
.MODEL MM NMOS LEVEL=1 IS=1e-32
+VTO=2.236 LAMBDA=0 KP=0.0932174
+CGSO=1.79115e-07 CGDO=1.0724e-11
RS 8 3 1.10523
D1 3 1 MD
.MODEL MD D IS=2.71011e-10 RS=0.0140826 N=1.5 BV=60
+IBV=1e-05 EG=1.16084 XTI=3.00131 TT=0
+CJO=3.41211e-11 VJ=4.67429 M=0.899864 FC=0.1
RDS 3 1 2.4e+11
RD 9 1 0.0001
RG 2 7 2.18034
D2 4 5 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=7.93181e-11 VJ=0.643298 M=0.9 FC=1e-08
D3 0 5 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.400165 RS=3.00002e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 1.58786e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 0 6 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.400165
.ENDS 2N7000/ON

*****************************************************************
* NXP BSP250
*
* Polarity P-Channel
* Ratings 30V/2.500000E-001OHMS/3A
*
* Date Created Thu Mar 01 07:53:14 2012
*
*****************************************************************
*
*****************************************************************
.SUBCKT BSP250/NXP DRAIN GATE SOURCE
LD DRAIN 5 4e-10
RLD2 DRAIN 5 1.00530964914873
RLD1 5 4 0.0023
LG GATE 1 7.26405326934776e-10
RLG GATE 1 1.82565571090143
LS SOURCE 8 1.13735483323052e-09
RLS2 SOURCE 8 2.85848447088148
RLS1 8 7 0.0131045079936694
RDS 7 4 13559322033.8983 TC=-0.005
RS 6 7 0.0001
RD 3 4 0.148633152899166 TC=0.00503727512341116,-2.27554779106754E-06
RBD 9 4 0.115360615544728 TC=0.00503727512341116,-2.27554779106754E-06
DBD 9 7 DBD
M1 3 2 6 6 MINT
RGS 2 6 105263157894.737
CGS 2 6 2.5066e-10
RG 1 2 21.3887954920063
* CGD
C11    11   12   1E-12
V11    11   0   0Vdc
G11    2 3 VALUE { V(13, 0)*I(V11) }
E11    12   0  2 3  1
E12    13   0  TABLE {V(12)}
+ -20     235.77
+ -16     237.01
+ -10     240.35
+ -5       250.06
+ -4       257.34
+ -3       276.79
+ -2       431.48
+ -1       428.09
+ -0.5   385.99
+ -0.2   356.32
+ -0.1   346.87
+ 0        331.71
+ 0.1     313.14
+ 0.2     298.72
+ 0.5     244.08
+ 1        174.7
+ 2        121.54
+ 3        100.17
+ 4        88.56
+ 5        78.74
+ 6        72.32
+ 8        63.43
+ 10      57.53
+ 12      53.21
+ 15      48.45
+ 20      43.13
+ 30      36.9
.MODEL MINT PMOS(Vto=-1.72688304464179 Kp=2.158555e+000 Nfs=195200000000 Eta=7800
+ Level=3 L=1e-4 W=1e-4 Gamma=0 Phi=0.6 Is=1e-24
+ Js=0 Pb=0.8 Cj=0 Cjsw=0 Cgso=0 Cgdo=0 Cgbo=0
+ Tox=1e-07 Xj=0
+ U0=600 Vmax=2000)
.MODEL DBD D(Bv=43.84767 Ibv=1.000000E-009 Rs=1E-6 Is=6.33228003630312e-15
+ N=1 M=0.38 VJ=0.69 Fc=0.5 Cjo=3.2774e-10 Tt=1.85e-08)
.ENDS

#drain gate source
VDD 1 0 DC 5V

#VA1 PMOS
X1 3 2 1 BSP250/NXP
#VA2 NMOS
X2 3 2 5 2N7000/ON
VA 2 0 PULSE(0V 5V 2s 0.0001 0.0001 2 4)

#VB1 PMOS
X3 3 4 1 BSP250/NXP
#VB2 NMOS
X4 5 4 0 2N7000/ON
VB 4 0 PULSE(0V 5V 1s 0.0001 0.0001 1 2)

.tran 0.001s 4s
